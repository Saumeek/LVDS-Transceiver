** sch_path: Git Files/Simulation Schematic/newVss.sch
**.subckt newVss VSS
*.iopin VSS
R2 net1 GND 5 m=1
L1 VSS net1 2n m=1
C1 VSS GND 20p m=1
**.ends
.GLOBAL GND
.end
